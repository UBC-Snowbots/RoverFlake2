Commit message: Still getting .nan

File: src/dev_arm/urdf/dev_arm.urdf (robot description, URDF)
Before this commit: robot dev_arm, 9 links, 8 joints
Links:
- link link_0: mass 0.4817433887173 -> None
